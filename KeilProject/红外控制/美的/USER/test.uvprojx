# Keil uVision project test.uvprojx, settings and files
target LED (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\DELAY;..\SYSTEM\sysum;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\EXTI;..\HARDWARE\TIME
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group SYSLIB
    ../SYSTEM/sysum/: system_stm32f10x.c core_cm3.c
    ./: startup_stm32f10x_hd.s
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/KEY/: KEY.c
    ../HARDWARE/DELAY/: DELAY.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/TIME/: time.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
